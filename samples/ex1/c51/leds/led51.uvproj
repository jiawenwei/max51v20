# Keil uVision project led51.uvproj, settings and files
target at89s52 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: led51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: KEIL
  group Source Group 1
    ./: main.c
