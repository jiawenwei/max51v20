# Keil uVision project ex2.uvproj, settings and files
target ex2 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: ex2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src
  group src
    ./: STARTUP.A51
    ./src/: main.c Led.c Timer.c
